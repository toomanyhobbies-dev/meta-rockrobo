# Mixer defaults for the A33 codec: speaker path on, at stock's levels

FILESEXTRAPATHS:prepend:rockrobo := "${THISDIR}/files:"
